# Keil uVision project STM32F103RCT6.uvprojx, settings and files
target Template (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RCT6 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\OLED_IIC;..\HARDWARE\TIMER;..\HARDWARE\FDC2214;..\HARDWARE\USART;..\HARDWARE\LCD;..\HARDWARE\ALGO;..\HARDWARE\CAPTURE;..\HARDWARE\Matching;..\HARDWARE\KEY;..\HARDWARE\Image2LCD;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group DRIVER
    ../HARDWARE/OLED_IIC/: oled.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/FDC2214/: fdc2214.c
    ../HARDWARE/CAPTURE/: capture.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ALGO/: algo.c
    ../HARDWARE/Matching/: Matching.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Image2LCD/: image2lcd.c Paper.c scissors.c stone.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
